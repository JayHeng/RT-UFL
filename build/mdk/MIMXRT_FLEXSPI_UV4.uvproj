# Keil uVision project MIMXRT_FLEXSPI_UV4.uvproj, settings and files
target MIMXRT_FLEXSPI (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MIMXRT_FLEXSPI_UV4_UFL
  AfterMake: cmd.exe /C copy "UV4_Objects\%L" ".\@L.FLM"
  c flags: Optim=3 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1176DVMAA_cm7
  c include: ..\..\src;..\..\src\devices;..\..\CMSIS\Core\Include
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --entry 0x1001
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group ufl
    ../../src/: ufl_common.h ufl_find_target.c ufl_find_target.h ufl_flexspi.c ufl_flexspi.h ufl_flexspi_nor_bsp.c ufl_flexspi_nor_bsp_imxrt101x.h ufl_flexspi_nor_bsp_imxrt101x_mdk.lib ufl_flexspi_nor_bsp_imxrt102x.h ufl_flexspi_nor_bsp_imxrt102x_mdk.lib ufl_flexspi_nor_bsp_imxrt105x.h ufl_flexspi_nor_bsp_imxrt105x_mdk.lib ufl_flexspi_nor_flash.c ufl_flexspi_nor_flash.h ufl_flexspi_nor_flash_imxrt5xx.h ufl_flexspi_nor_flash_imxrt6xx.h ufl_flexspi_nor_flash_imxrt101x.h ufl_flexspi_nor_flash_imxrt102x.h ufl_flexspi_nor_flash_imxrt105x.h ufl_flexspi_nor_flash_imxrt106x.h ufl_flexspi_nor_flash_imxrt117x.h ufl_flexspi_nor_flash_imxrt118x.h ufl_hardware_init.h ufl_hardware_init_imxrt5xx.c ufl_hardware_init_imxrt6xx.c ufl_hardware_init_imxrt101x.c ufl_hardware_init_imxrt102x.c ufl_hardware_init_imxrt105x.c ufl_hardware_init_imxrt106x.c ufl_hardware_init_imxrt117x.c ufl_hardware_init_imxrt118x.c ufl_rom_api.c ufl_rom_api.h ufl_rom_api_imxrt5xx.h ufl_rom_api_imxrt6xx.h ufl_rom_api_imxrt106x.h ufl_rom_api_imxrt117x.h ufl_rom_api_imxrt118x.h ufl_auto_probe_flash.c ufl_auto_probe_flash.h ufl_main.c
  group Device Driver
    ../../src/devices/: fsl_anatop.c fsl_anatop_ai.c fsl_clock.c fsl_common.c
