# IAR project FlashIMXRT_FlexSPI.ewp, settings and files
configuration FlashIMXRT1060_FlexSPI (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MIMXRT1176DVMAA_cm7
  ICCARM.CCIncludePath2: ; ..\..\src\; ..\..\src\devices\; ..\..\CMSIS\Core\Include\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashIMXRT_FlexSPI.bin
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: FlashIMXRT_RAM512K.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: FlashIMXRT_FlexSPI.c
  group Device Driver
    ../../src/devices/: fsl_anatop.c fsl_anatop_ai.c fsl_clock.c fsl_common.c
  group Framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
  group ufl
    ../../src/: ufl_auto_probe_flash.c ufl_auto_probe_flash.h ufl_common.h ufl_find_target.c ufl_find_target.h ufl_flexspi_nor_flash.h ufl_flexspi_nor_flash_imxrt106x.h ufl_flexspi_nor_flash_imxrt117x.h ufl_flexspi_nor_flash_imxrt5xx.h ufl_flexspi_nor_flash_imxrt6xx.h ufl_hardware_init.h ufl_hardware_init_imxrt106x.c ufl_hardware_init_imxrt117x.c ufl_hardware_init_imxrt5xx.c ufl_hardware_init_imxrt6xx.c ufl_main.c ufl_rom_api.c ufl_rom_api.h ufl_rom_api_imxrt106x.h ufl_rom_api_imxrt117x.h ufl_rom_api_imxrt5xx.h ufl_rom_api_imxrt6xx.h
