# Keil uVision project MIMXRT105x_HYPER.uvprojx, settings and files
target RT105x_Hyper_Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x018000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MIMXRT105x_EVK_Heyper
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT105x_EVK_HYPER_4KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1052DVL6B
  c include: .\Sources;.\Sources\rom;..\..\..\..\CMSIS\Include
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg_s26ks512s.c
  group Device Description
    ./: FlashDev_s26ks512s.c
  group Sources
    ./Sources/: fsl_clock.c
    ./Sources/rom/: bl_api.c bl_clock_config_MIMXRT1052.c bl_flexspi.c flexspi_nor_flash.c hardware_init_MIMXRT1052.c microseconds_sysclk.c
target ARM7_ARM9 (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: as above
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "@L.FLX"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: ROM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
