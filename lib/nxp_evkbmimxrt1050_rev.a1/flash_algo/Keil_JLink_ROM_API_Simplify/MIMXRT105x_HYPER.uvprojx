# Keil uVision project MIMXRT105x_HYPER.uvprojx, settings and files
target RT105x_Hyper_Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: MIMXRT105x_EVK_Heyper
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT105x_EVK_HYPER_4KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1052DVL6B
  c include: .\Sources;.\Sources\rom;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg_s26ks512s.c
  group Device Description
    ./: FlashDev_s26ks512s.c
  group Sources
    ./Sources/rom/: bl_flexspi.c flexspi_nor_flash.c app.c flexspi_hardware_init_rt1050.lib
target ARM7_ARM9 (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x018000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "@L.FLX"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: ROM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
