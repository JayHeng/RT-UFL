# IAR project FlashIMXRT_FlexSPI.ewp, settings and files
configuration FlashIMXRT_FlexSPI (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MIMXRT1021DAG5A
  ICCARM.CCIncludePath2: ; Sources\; Sources\rom\; ..\..\..\..\CMSIS\Core\Include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashIMXRT_FlexSPI.bin
  ILINK.IlinkOutputFile: FlashIMXRT_FLEXSPI_UFL.out
  ILINK.IlinkIcfFile: FlashIMXRT_RAM64K.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: FlashIMXRT_FlexSPI.c
    Sources/rom/: flexspi_hardware_init_rt1020.c
  group Framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
