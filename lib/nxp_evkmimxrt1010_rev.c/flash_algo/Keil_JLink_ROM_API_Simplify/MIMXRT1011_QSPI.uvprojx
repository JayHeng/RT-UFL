# Keil uVision project MIMXRT1011_QSPI.uvprojx, settings and files
target RT1011 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: hardware_init_rt1010
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT1011_QuadSPI_4KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1011DAE5A
  c include: .\Sources;.\Sources\rom;..\..\..\Include
  memory RVCT4: ROM 0x1000 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --entry 0x1001
  group Program Functions
    ./: FlashPrg_at25sf128a.c
  group Device Description
    ./: FlashDev_at25sf128a.c
  group Sources
    ./Sources/ROM/: bl_flexspi.c
    ./Sources/rom/: flexspi_nor_flash.c app.c flexspi_hardware_init_rt1010.lib
software components: CMSIS:CORE 5.4.0
