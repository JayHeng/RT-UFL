# Keil uVision project ufl_unittest.uvprojx, settings and files
target ufl_unittest debug (6140000::V6.14::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: ufl_unittest.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1052DVL6B, UNIT_TEST
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../..;../../../../src;../../../../src/devices;../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_ram.scf
  link misc: --remove
  group source
    ../: main.c system_MIMXRT1052.c
    ./: startup_MIMXRT1052.s
    ../../../../src/: ufl_auto_probe_flash.c ufl_auto_probe_flash.h ufl_common.h ufl_find_target.c ufl_find_target.h ufl_flexspi.c ufl_flexspi.h ufl_flexspi_nor_bsp.c ufl_flexspi_nor_bsp_imxrt101x.h ufl_flexspi_nor_bsp_imxrt101x_mdk.lib ufl_flexspi_nor_bsp_imxrt102x.h ufl_flexspi_nor_bsp_imxrt102x_mdk.lib ufl_flexspi_nor_bsp_imxrt105x.h ufl_flexspi_nor_bsp_imxrt105x_mdk.lib ufl_flexspi_nor_flash.c ufl_flexspi_nor_flash.h ufl_flexspi_nor_flash_imxrt5xx.h ufl_flexspi_nor_flash_imxrt6xx.h ufl_flexspi_nor_flash_imxrt101x.h ufl_flexspi_nor_flash_imxrt102x.h ufl_flexspi_nor_flash_imxrt105x.h ufl_flexspi_nor_flash_imxrt106x.h ufl_flexspi_nor_flash_imxrt117x.h ufl_hardware_init.h ufl_hardware_init_imxrt5xx.c ufl_hardware_init_imxrt6xx.c ufl_hardware_init_imxrt101x.c ufl_hardware_init_imxrt102x.c ufl_hardware_init_imxrt105x.c ufl_hardware_init_imxrt106x.c ufl_hardware_init_imxrt117x.c ufl_main.c ufl_rom_api.c ufl_rom_api.h ufl_rom_api_imxrt5xx.h ufl_rom_api_imxrt6xx.h ufl_rom_api_imxrt106x.h ufl_rom_api_imxrt117x.h
target ufl_unittest release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1052/xip;../../../xip;../../../../../devices/MIMXRT1052/utilities
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_ram.scf
  link misc: --remove
