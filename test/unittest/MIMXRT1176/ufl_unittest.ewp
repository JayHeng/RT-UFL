# IAR project ufl_unittest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; UNIT_TEST; CPU_MIMXRT1176DVMAA_cm7
  ICCARM.CCIncludePath2: ; ../../../src; ../../../src/devices; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ufl_unittest.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062CVJ5A
  ICCARM.CCIncludePath2: ..; ../../../src; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  group (top)
    ../../../src/devices/: fsl_anatop.c fsl_anatop_ai.c fsl_clock.c fsl_common.c
    ./: main.c startup_MIMXRT1176_cm7.s system_MIMXRT1176_cm7.c
    ../../../src/: ufl_auto_probe_flash.c ufl_auto_probe_flash.h ufl_common.h ufl_find_target.c ufl_find_target.h ufl_flexspi.c ufl_flexspi.h ufl_flexspi_nor_bsp.c ufl_flexspi_nor_bsp_imxrt105x.h ufl_flexspi_nor_bsp_imxrt105x_mdk.lib ufl_flexspi_nor_flash.c ufl_flexspi_nor_flash.h ufl_flexspi_nor_flash_imxrt105x.h ufl_flexspi_nor_flash_imxrt106x.h ufl_flexspi_nor_flash_imxrt117x.h ufl_flexspi_nor_flash_imxrt5xx.h ufl_flexspi_nor_flash_imxrt6xx.h ufl_hardware_init.h ufl_hardware_init_imxrt105x.c ufl_hardware_init_imxrt106x.c ufl_hardware_init_imxrt117x.c ufl_hardware_init_imxrt5xx.c ufl_hardware_init_imxrt6xx.c ufl_main.c ufl_rom_api.c ufl_rom_api.h ufl_rom_api_imxrt106x.h ufl_rom_api_imxrt117x.h ufl_rom_api_imxrt5xx.h ufl_rom_api_imxrt6xx.h
