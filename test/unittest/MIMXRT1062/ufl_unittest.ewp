# IAR project ufl_unittest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1062CVJ5A
  ICCARM.CCIncludePath2: ; ../../../src; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ufl_unittest.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062CVJ5A
  ICCARM.CCIncludePath2: ..; ../../../src; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c startup_MIMXRT1062.s system_MIMXRT1062.c
    ../../../src/: ufl_common.h ufl_find_target.c ufl_find_target.h ufl_flexspi_nor_flash.h ufl_flexspi_nor_flash_imxrt106x.h ufl_flexspi_nor_flash_imxrt117x.h ufl_flexspi_nor_flash_imxrt5xx.h ufl_flexspi_nor_flash_imxrt6xx.h ufl_hardware_init.h ufl_hardware_init_imxrt106x.c ufl_hardware_init_imxrt117x.c ufl_hardware_init_imxrt5xx.c ufl_hardware_init_imxrt6xx.c ufl_main.c ufl_rom_api.c ufl_rom_api.h ufl_rom_api_imxrt106x.h ufl_rom_api_imxrt117x.h ufl_rom_api_imxrt5xx.h ufl_rom_api_imxrt6xx.h
